# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../Third_Party/SFUD/inc;../Third_Party/EasyLogger/easylogger/inc;../Third_Party/MultiTimer;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Third_Party/MultiButton;../Third_Party/FreeRTOS-Kernel/include;../Third_Party/FreeRTOS-Kernel;../Third_Party/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F;../Third_Party/littlefs-2.10.2;../Third_Party/lvgl-release-v8.4.0;../Third_Party/lvgl-release-v8.4.0/src;../Third_Party/lvgl-release-v8.4.0/porting;../Third_Party/letter-shell/src;../Third_Party/letter-shell/demo/stm32-freertos;..\Third_Party\zephyr_smf;..\Third_Party\RingBuffer\lwrb-develop\lwrb;..\Third_Party\RingBuffer\zephyr_ringbuf;..\Third_Party\Fal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\stm32f407_mem_alloc.sct
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fsmc.c i2c.c rtc.c sdio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Third_Party/SFUD
    ../Third_Party/SFUD/inc/: sfud.h sfud_cfg.h sfud_def.h sfud_flash_def.h
    ../Third_Party/SFUD/port/: sfud_port.c
    ../Third_Party/SFUD/src/: sfud.c sfud_sfdp.c
  group Third_Party/Easy_Log
    ../Third_Party/EasyLogger/easylogger/inc/: elog.h elog_cfg.h
    ../Third_Party/EasyLogger/easylogger/port/: elog_port.c
    ../Third_Party/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Third_Party/MultiTimer
    ../Third_Party/MultiTimer/: MultiTimer.c MultiTimer.h
  group Third_Party/LittleFs
    ../Third_Party/littlefs-2.10.2/: lfs.c lfs.h lfs_util.c lfs_util.h lfs_config.h lfs_config.c
  group Third_Party/MultiButton
    ../Third_Party/MultiButton/: multi_button.c multi_button.h
  group Third_Party/FreeRtos
    ../Third_Party/FreeRTOS-Kernel/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Third_Party/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Third_Party/Lvgl_Port
    ../Third_Party/lvgl-release-v8.4.0/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
    ../Third_Party/lvgl-release-v8.4.0/: lv_conf.h lvgl.h
  group Third_Party/Lvgl/Src/Core
    ../Third_Party/lvgl-release-v8.4.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Third_Party/Lvgl/Src/Draw
    ../Third_Party/lvgl-release-v8.4.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Third_Party/lvgl-release-v8.4.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Third_Party/Lvgl/Src/Extra
    ../Third_Party/lvgl-release-v8.4.0/src/extra/layouts/flex/: lv_flex.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/layouts/grid/: lv_grid.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/bmp/: lv_bmp.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/freetype/: lv_freetype.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/png/: lodepng.c lv_png.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/rlottie/: lv_rlottie.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/gridnav/: lv_gridnav.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/ime/: lv_ime_pinyin.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/imgfont/: lv_imgfont.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/monkey/: lv_monkey.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/msg/: lv_msg.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/others/snapshot/: lv_snapshot.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/themes/basic/: lv_theme_basic.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/themes/default/: lv_theme_default.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/themes/mono/: lv_theme_mono.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/animimg/: lv_animimg.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/chart/: lv_chart.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/led/: lv_led.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/list/: lv_list.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/menu/: lv_menu.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/meter/: lv_meter.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/span/: lv_span.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/spinner/: lv_spinner.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/tabview/: lv_tabview.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/tileview/: lv_tileview.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/widgets/win/: lv_win.c
    ../Third_Party/lvgl-release-v8.4.0/src/extra/: lv_extra.c
  group Third_Party/Lvgl/Src/Font
    ../Third_Party/lvgl-release-v8.4.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Third_Party/Lvgl/Src/Gpu
    ../Third_Party/lvgl-release-v8.4.0/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Third_Party/lvgl-release-v8.4.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Third_Party/Lvgl/Src/Hal
    ../Third_Party/lvgl-release-v8.4.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Third_Party/Lvgl/Src/Misc
    ../Third_Party/lvgl-release-v8.4.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Third_Party/Lvgl/Src/Widgets
    ../Third_Party/lvgl-release-v8.4.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Third_Party/Lvgl/Demo/Music
    ../Third_Party/lvgl-release-v8.4.0/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Third_Party/lvgl-release-v8.4.0/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group Third_Party/Lvgl/Demo/Stress
    ../Third_Party/lvgl-release-v8.4.0/demos/stress/: lv_demo_stress.c
  group Third_Party/letter-shell
    ../Third_Party/letter-shell/src/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h
    ../Third_Party/letter-shell/demo/stm32-freertos/: shell_port.c shell_port.h
  group Third_Party/SMF
    ../Third_Party/zephyr_smf/: smf.c
  group Third_Party/RingBuffer
    ../Third_Party/RingBuffer/zephyr_ringbuf/: ring_buffer.c
    ../Third_Party/RingBuffer/lwrb-develop/lwrb/: lwrb.c lwrb_ex.c
  group Third_Party/FAL
    ../Third_Party/Fal/: fal.h fal_def.h fal_cfg.h fal.c fal_flash.c fal_partition.c fal_flash_sfud_port.c fal_flash_stm32f4.c fal_flash_eeprom.c
  group User
    ../User/: app.c w25qxx.c sys_time.c nvs_flash.c sd_card.c malloc.c ble.c esp8266.c at24c02.c ui.c iap.c eth.c button.c buzzer.c led.c log.c lcd.c xtp_2046.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0
